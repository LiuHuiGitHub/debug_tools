# Keil uVision project debug_tools.uvproj, settings and files
target project (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: debug_tools +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: ..\System;..\User;..\Hwa;..\Drivers;..\App
  link misc: REMOVEUNUSED
  group System
    ../System/: sys_delay.c sys_uart.c
  group User
    ../User/: main.c
  group Hwa
    ../Hwa/: hwa_uart.c
