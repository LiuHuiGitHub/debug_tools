# IAR project debug_tools.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105K6 STM8S105K6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: DEBUG
  ICCSTM8.CCIncludePath2: ..\USER; ..\System; ..\Hwa; ..\Driver; ..\App; ..\ZLG_GUI
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: debug_tools.hex
  ILINK.IlinkOutputFile: debug_tools.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  ICCSTM8.CCDefines: NENCRYPT; NDEBUG
  ICCSTM8.CCIncludePath2: ..\USER; ..\System; ..\Hwa; ..\Driver; ..\App
  OBJCOPY.OOCOutputFile: BZ3101.hex
  ILINK.IlinkOutputFile: BZ3101.out
  group Hwa
    ../Hwa/: hwa_uart.c
  group System
    ../System/: sys_clock.c sys_scheduler.c sys_task.c sys_uart.c sys_vector.c
